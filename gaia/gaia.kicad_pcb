# Repository wenbu/keyboard

File readme.md:

KiCad component library, PCB schematics, layouts, etc. for custom keyboards

## KiCad design gaia/gaia.kicad_pcb

Schematic: gaia.sch

Parts:
C1, C2, C3, C7: 100nF; bwu-ceramic-capacitor-0805
C4, C5: 10pF; bwu-ceramic-capacitor-0805
C6, C8: 1µF; bwu-electrolyte-capacitor-0805
CON1: USB-MINI-B WM17115-ND; USB-MINI-B-WM17115-ND
D0:7: D0:7; SOD-123
D1:7: D1:7; SOD-123
D2:7: D2:7; SOD-123
D3:7: D3:7; SOD-123
D4:7: D4:7; SOD-123
IC1: ATMEGA32U4; TQFP44
IC2, IC3, IC4: IS31FL3731; SSOP-28
R1, R2: 22Ω; bwu-resistor-0805
R3: 1kΩ; bwu-resistor-0805
R4, R5, R6: 20kΩ; bwu-resistor-0805
S0:1, S0:2, S0:3, S0:4, S0:5, S0:6, S0:8, S0:9, S0:10, S0:11, S0:12, S1:1, S1:2, S1:3, S1:4, S1:5, S1:6, S1:8, S1:9, S1:10, S1:11, S1:12, S2:1, S2:2, S2:3, S2:4, S2:5, S2:6, S2:8, S2:9, S2:10, S2:11, S2:12, S3:1, S3:2, S3:3, S3:4, S3:5, S3:6, S3:8, S3:9, S3:10, S3:11, S3:12, S4:1, S4:2, S4:3, S4:4, S4:5, S4:6, S4:8, S4:9, S4:10, S4:11, S4:12, S5:1, S5:2, S5:3, S5:4, S5:9, S5:10, S5:11, S5:12: MX1A-DIODE-RGB; bwu-mx1a-1u-rgb-led-reverse
S0:7, S1:7, S2:7, S3:7, S4:7: MX1A-DIODE-RGB; bwu-mx1a-1u-rgb-led-no-diode-reverse
S1:0, S1:13, S2:0, S2:13, S3:0, S3:13, S4:0, S4:13, S5:0, S5:13: MX1A-DIODE-RGB; bwu-mx1a-150u-rgb-reverse
S5:5, S5:6, S5:7, S5:8: MX1A-DIODE-RGB; bwu-mx1a-2u-rgb-reverse
SW1: SW423CT-ND; bwu-SW423CT-ND
Y1: 16MHz; bwu-ABM8G-16.000MHZ-4Y-T3

Connections:
/AREF: C7.1, IC1.42 (AREF)
/C0: IC1.22 ((XCK1/~CTS~)PD5), S1:0.3, S2:0.3, S3:0.3, S4:0.3, S5:0.3
/C1: IC1.25 ((ICP1/ADC8)PD4), S0:1.3, S1:1.3, S2:1.3, S3:1.3, S4:1.3, S5:1.3
/C2: IC1.26 ((T1/~OC4D~/ADC9)PD6), S0:2.3, S1:2.3, S2:2.3, S3:2.3, S4:2.3, S5:2.3
/C3: IC1.27 ((T0/OC4D/ADC10)PD7), S0:3.3, S1:3.3, S2:3.3, S3:3.3, S4:3.3, S5:3.3
/C4: IC1.28 ((PCINT4/ADC11)PB4), S0:4.3, S1:4.3, S2:4.3, S3:4.3, S4:4.3, S5:4.3
/C5: IC1.29 ((PCINT5/OC1A/~OC4B~/ADC12)PB5), S0:5.3, S1:5.3, S2:5.3, S3:5.3, S4:5.3, S5:5.3
/C6: IC1.30 ((PCINT6/OC1B/OC4B/ADC13)PB6), S0:6.3, S1:6.3, S2:6.3, S3:6.3, S4:6.3, S5:6.3
/C7: D0:7.1 (A), D1:7.1 (A), D2:7.1 (A), D3:7.1 (A), D4:7.1 (A), IC1.32 ((ICP3/CLK0/OC4A)PC7), S5:7.3
/C8: IC1.36 ((ADC7/TDI)PF7), S0:8.3, S1:8.3, S2:8.3, S3:8.3, S4:8.3, S5:8.3
/C9: IC1.37 ((ADC6/TDO)PF6), S0:9.3, S1:9.3, S2:9.3, S3:9.3, S4:9.3, S5:9.3
/CA: IC1.38 ((ADC5/TMS)PF5), S0:10.3, S1:10.3, S2:10.3, S3:10.3, S4:10.3, S5:10.3
/CA1_1: IC2.21, S1:0.4, S1:1.4, S1:2.4, S1:3.4, S1:4.4, S1:5.4, S1:6.4
/CA1_2: IC3.21, S3:0.4, S3:1.4, S3:2.4, S3:3.4, S3:4.4, S3:5.4, S3:6.4
/CA1_3: IC4.21, S5:0.4, S5:1.4, S5:2.4, S5:3.4, S5:4.4, S5:5.4, S5:6.4
/CA2_1: IC2.22, S1:0.5, S1:1.6, S1:2.6, S1:3.6, S1:4.6, S1:5.6, S1:6.6
/CA2_2: IC3.22, S2:0.5, S3:0.5, S3:1.6, S3:2.6, S3:3.6, S3:4.6, S3:5.6, S3:6.6
/CA2_3: IC4.22, S4:0.5, S5:0.5, S5:1.6, S5:2.6, S5:3.6, S5:4.6, S5:5.6, S5:6.6
/CA3_1: IC2.23, S0:1.5, S1:0.6, S1:1.5, S1:2.7, S1:3.7, S1:4.7, S1:5.7, S1:6.7
/CA3_2: IC3.23, S2:1.5, S3:0.6, S3:1.5, S3:2.7, S3:3.7, S3:4.7, S3:5.7, S3:6.7
/CA3_3: IC4.23, S4:1.5, S5:0.6, S5:1.5, S5:2.7, S5:3.7, S5:4.7, S5:5.7, S5:6.7
/CA4_1: IC2.24, S0:2.5, S1:0.7, S1:1.7, S1:2.5
/CA4_2: IC3.24, S2:2.5, S3:0.7, S3:1.7, S3:2.5
/CA4_3: IC4.24, S4:2.5, S5:0.7, S5:1.7, S5:2.5
/CA5_1: IC2.25, S0:3.5, S1:3.5
/CA5_2: IC3.25, S2:3.5, S3:3.5
/CA5_3: IC4.25, S4:3.5, S5:3.5
/CA6_1: IC2.26, S0:4.5, S0:5.4, S0:6.4, S1:4.5
/CA6_2: IC3.26, S2:4.5, S2:5.4, S2:6.4, S3:4.5
/CA6_3: IC4.26, S4:4.5, S4:5.4, S4:6.4, S5:4.5
/CA7_1: IC2.27, S0:1.4, S0:2.4, S0:3.4, S0:4.4, S0:5.5, S0:6.6, S1:5.5
/CA7_2: IC3.27, S2:0.4, S2:1.4, S2:2.4, S2:3.4, S2:4.4, S2:5.5, S2:6.6, S3:5.5
/CA7_3: IC4.27, S4:0.4, S4:1.4, S4:2.4, S4:3.4, S4:4.4, S4:5.5, S4:6.6, S5:5.5
/CA8_1: IC2.28, S0:1.6, S0:2.6, S0:3.6, S0:4.6, S0:5.6, S0:6.5, S1:6.5
/CA8_2: IC3.28, S2:0.6, S2:1.6, S2:2.6, S2:3.6, S2:4.6, S2:5.6, S2:6.5, S3:6.5
/CA8_3: IC4.28, S4:0.6, S4:1.6, S4:2.6, S4:3.6, S4:4.6, S4:5.6, S4:6.5, S5:6.5
/CA9_1: IC2.1, S0:1.7, S0:2.7, S0:3.7, S0:4.7, S0:5.7, S0:6.7
/CA9_2: IC3.1, S2:0.7, S2:1.7, S2:2.7, S2:3.7, S2:4.7, S2:5.7, S2:6.7
/CA9_3: IC4.1, S4:0.7, S4:1.7, S4:2.7, S4:3.7, S4:4.7, S4:5.7, S4:6.7
/CB: IC1.39 ((ADC4/TCK)PF4), S0:11.3, S1:11.3, S2:11.3, S3:11.3, S4:11.3, S5:11.3
/CB1_1: IC2.7, S1:7.4, S1:8.4, S1:9.4, S1:10.4, S1:11.4, S1:12.4, S1:13.4
/CB1_2: IC3.7, S3:7.4, S3:8.4, S3:9.4, S3:10.4, S3:11.4, S3:12.4, S3:13.4
/CB1_3: IC4.7, S5:7.4, S5:8.4, S5:9.4, S5:10.4, S5:11.4, S5:12.4, S5:13.4
/CB2_1: IC2.8, S0:7.5, S1:7.5, S1:8.6, S1:9.6, S1:10.6, S1:11.6, S1:12.6, S1:13.6
/CB2_2: IC3.8, S2:7.5, S3:7.5, S3:8.6, S3:9.6, S3:10.6, S3:11.6, S3:12.6, S3:13.6
/CB2_3: IC4.8, S4:7.5, S5:7.5, S5:8.6, S5:9.6, S5:10.6, S5:11.6, S5:12.6, S5:13.6
/CB3_1: IC2.9, S0:8.5, S1:7.6, S1:8.5, S1:9.7, S1:10.7, S1:11.7, S1:12.7, S1:13.7
/CB3_2: IC3.9, S2:8.5, S3:7.6, S3:8.5, S3:9.7, S3:10.7, S3:11.7, S3:12.7, S3:13.7
/CB3_3: IC4.9, S4:8.5, S5:7.6, S5:8.5, S5:9.7, S5:10.7, S5:11.7, S5:12.7, S5:13.7
/CB4_1: IC2.10, S0:9.5, S1:7.7, S1:8.7, S1:9.5
/CB4_2: IC3.10, S2:9.5, S3:7.7, S3:8.7, S3:9.5
/CB4_3: IC4.10, S4:9.5, S5:7.7, S5:8.7, S5:9.5
/CB5_1: IC2.11, S0:10.5, S1:10.5
/CB5_2: IC3.11, S2:10.5, S3:10.5
/CB5_3: IC4.11, S4:10.5, S5:10.5
/CB6_1: IC2.12, S0:11.5, S0:12.4, S1:11.5
/CB6_2: IC3.12, S2:11.5, S2:12.4, S2:13.4, S3:11.5
/CB6_3: IC4.12, S4:11.5, S4:12.4, S4:13.4, S5:11.5
/CB7_1: IC2.13, S0:7.4, S0:8.4, S0:9.4, S0:10.4, S0:11.4, S0:12.5, S1:12.5
/CB7_2: IC3.13, S2:7.4, S2:8.4, S2:9.4, S2:10.4, S2:11.4, S2:12.5, S2:13.6, S3:12.5
/CB7_3: IC4.13, S4:7.4, S4:8.4, S4:9.4, S4:10.4, S4:11.4, S4:12.5, S4:13.6, S5:12.5
/CB8_1: IC2.14, S0:7.6, S0:8.6, S0:9.6, S0:10.6, S0:11.6, S0:12.6, S1:13.5
/CB8_2: IC3.14, S2:7.6, S2:8.6, S2:9.6, S2:10.6, S2:11.6, S2:12.6, S2:13.5, S3:13.5
/CB8_3: IC4.14, S4:7.6, S4:8.6, S4:9.6, S4:10.6, S4:11.6, S4:12.6, S4:13.5, S5:13.5
/CB9_1: IC2.15, S0:7.7, S0:8.7, S0:9.7, S0:10.7, S0:11.7, S0:12.7
/CB9_2: IC3.15, S2:7.7, S2:8.7, S2:9.7, S2:10.7, S2:11.7, S2:12.7, S2:13.7
/CB9_3: IC4.15, S4:7.7, S4:8.7, S4:9.7, S4:10.7, S4:11.7, S4:12.7, S4:13.7
/CC: IC1.40 ((ADC1)PF1), S0:12.3, S1:12.3, S2:12.3, S3:12.3, S4:12.3, S5:12.3
/CD: IC1.41 ((ADC0)PF0), S1:13.3, S2:13.3, S3:13.3, S4:13.3, S5:13.3
/D+: IC1.4 (D+), R2.1
/D-: IC1.3 (D-), R1.1
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, CON1.5 (GND), CON1.6 (SHELL1), CON1.7 (SHELL2), IC1.5 (UGnd), IC1.15 (GND), IC1.23 (GND), IC1.35 (GND), IC1.43 (GND), IC2.5, IC2.18, IC3.5, IC4.5, R3.1, R4.2, R5.2, R6.2, SW1.3, SW1.4, Y1.2, Y1.4
/R0: IC1.1 ((INT6/AIN0)PE6), S0:1.1, S0:2.1, S0:3.1, S0:4.1, S0:5.1, S0:6.1, S0:7.1, S0:8.1, S0:9.1, S0:10.1, S0:11.1, S0:12.1
/R1: IC1.8 ((SS/PCINT0)PB0), S1:0.1, S1:1.1, S1:2.1, S1:3.1, S1:4.1, S1:5.1, S1:6.1, S1:7.1, S1:8.1, S1:9.1, S1:10.1, S1:11.1, S1:12.1, S1:13.1
/R2: IC1.9 ((PCINT1/SCLK)PB1), S2:0.1, S2:1.1, S2:2.1, S2:3.1, S2:4.1, S2:5.1, S2:6.1, S2:7.1, S2:8.1, S2:9.1, S2:10.1, S2:11.1, S2:12.1, S2:13.1
/R3: IC1.10 ((PDI/PCINT2/MOSI)PB2), S3:0.1, S3:1.1, S3:2.1, S3:3.1, S3:4.1, S3:5.1, S3:6.1, S3:7.1, S3:8.1, S3:9.1, S3:10.1, S3:11.1, S3:12.1, S3:13.1
/R4: IC1.11 ((PDO/PCINT3/MISO)PB3), S4:0.1, S4:1.1, S4:2.1, S4:3.1, S4:4.1, S4:5.1, S4:6.1, S4:7.1, S4:8.1, S4:9.1, S4:10.1, S4:11.1, S4:12.1, S4:13.1
/R5: IC1.12 ((PCINT7/OC0A/OC1C/~RTS~)PB7), S5:0.1, S5:1.1, S5:2.1, S5:3.1, S5:4.1, S5:5.1, S5:6.1, S5:7.1, S5:8.1, S5:9.1, S5:10.1, S5:11.1, S5:12.1, S5:13.1
/RESET: IC1.13 (~RESET~), SW1.2
/SCL: IC1.18 ((OC0B/SCL/INT0)PD0), IC2.20, IC3.18, IC3.20, IC4.20
/SDA: IC1.19 ((SDA/INT1)PD1), IC2.19, IC3.19, IC4.18, IC4.19
/SDB: IC1.31 ((OC3A/~OC4A~)PC6), IC2.3, IC3.3, IC4.3
/UCAP: C8.1, IC1.6 (Ucap)
/USB_D+: CON1.3 (D+), R2.2
/USB_D-: CON1.2 (D-), R1.2
/VCC: C1.1, C2.1, C3.1, C6.1, CON1.1 (VBUS), IC1.2 (UVcc), IC1.7 (VBus), IC1.14 (VCC), IC1.24 (AVCC), IC1.34 (VCC), IC1.44 (AVCC), IC2.2, IC3.2, IC4.2
/XTAL+: C4.1, IC1.16 (XTAL2), Y1.3
/XTAL-: C5.1, IC1.17 (XTAL1), Y1.1
unnamed: D0:7.2 (K), S0:7.2
unnamed: D1:7.2 (K), S1:7.2
unnamed: D2:7.2 (K), S2:7.2
unnamed: D3:7.2 (K), S3:7.2
unnamed: D4:7.2 (K), S4:7.2
unnamed: IC1.33 ((~HWB~)PE2), R3.2
unnamed: IC2.6, R4.1
unnamed: IC3.6, R5.1
unnamed: IC4.6, R6.1

Board: 2 copper layers, 108 parts (0 on the bottom side), 97 nets.

## KiCad design hermes.kicad_pcb

Parts:
C1, C2, C3, C7: 100nF; bwu-ceramic-capacitor-0805
C4, C5: 10pF; bwu-ceramic-capacitor-0805
C6, C8: 1µF; bwu-electrolyte-capacitor-0805
C9: 220nF
C10: 100nF
CON1: USB-MINI-B WM17115-ND; USB-MINI-B-WM17115-ND
D0:0, D0:1, D0:2, D0:3, D0:4, D0:5, D0:6, D0:7, D0:8, D0:9, D0:10, D0:11, D0:12, D0:13, D1:0, D1:1, D1:2, D1:3, D1:4, D1:5, D1:6, D1:7, D1:8, D1:9, D1:10, D1:11, D1:12, D1:13, D2:0, D2:1, D2:2, D2:3, D2:4, D2:5, D2:6, D2:7, D2:8, D2:9, D2:10, D2:11, D2:12, D2:13, D3:0, D3:1, D3:2, D3:3, D3:4, D3:5, D3:6, D3:7, D3:8, D3:9, D3:10, D3:11, D3:12, D3:13, D4:0, D4:1, D4:2, D4:3, D4:5, D4:6, D4:8, D4:10, D4:11, D4:12, D4:13: D; SOD-123
IC1: ATMEGA32U4; TQFP44
IC2: IS31FL3731
LED1, LED2, LED3, LED4, LED5, LED6, LED7: 5060BRG4; bwu-5060BRG4
R1, R2: 22Ω; bwu-resistor-0805
R3: 1kΩ; bwu-resistor-0805
R4, R5, R6: 4.7kΩ; bwu-resistor-0805
R7: 100kΩ; bwu-resistor-0805
R8: 20kΩ; bwu-resistor-0805
S0:0: K_ESC; bwu-mx1a-150u
S0:1: K_1; bwu-mx1a-1u
S0:2: K_2; bwu-mx1a-1u
S0:3: K_3; bwu-mx1a-1u
S0:4: K_4; bwu-mx1a-1u
S0:5: K_5; bwu-mx1a-1u
S0:6: K_BL1; bwu-mx1a-1u
S0:7: K_BL2; bwu-mx1a-1u
S0:8: K_6; bwu-mx1a-1u
S0:9: K_7; bwu-mx1a-1u
S0:10: K_8; bwu-mx1a-1u
S0:11: K_9; bwu-mx1a-1u
S0:12: K_0; bwu-mx1a-1u
S0:13: K_EQUAL; bwu-mx1a-150u
S1:0: K_TAB; bwu-mx1a-150u
S1:1: K_QUOTE; bwu-mx1a-1u
S1:2: K_COMMA; bwu-mx1a-1u
S1:3: K_PRD; bwu-mx1a-1u
S1:4: K_P; bwu-mx1a-1u
S1:5: K_Y; bwu-mx1a-1u
S1:6: K_HOME; bwu-mx1a-1u
S1:7: K_PGUP; bwu-mx1a-1u
S1:8: K_F; bwu-mx1a-1u
S1:9: K_G; bwu-mx1a-1u
S1:10: K_C; bwu-mx1a-1u
S1:11: K_R; bwu-mx1a-1u
S1:12: K_L; bwu-mx1a-1u
S1:13: K_SLASH; bwu-mx1a-150u
S2:0: K_BKTK; bwu-mx1a-150u
S2:1: K_A; bwu-mx1a-1u
S2:2: K_O; bwu-mx1a-1u
S2:3: K_E; bwu-mx1a-1u
S2:4: K_U; bwu-mx1a-1u
S2:5: K_I; bwu-mx1a-1u
S2:6: K_END; bwu-mx1a-1u
S2:7: K_PGDN; bwu-mx1a-1u
S2:8: K_D; bwu-mx1a-1u
S2:9: K_H; bwu-mx1a-1u
S2:10: K_T; bwu-mx1a-1u
S2:11: K_N; bwu-mx1a-1u
S2:12: K_S; bwu-mx1a-1u
S2:13: K_DASH; bwu-mx1a-150u
S3:0: K_LSHFT; bwu-mx1a-150u
S3:1: K_SMCLN; bwu-mx1a-1u
S3:2: K_Q; bwu-mx1a-1u
S3:3: K_J; bwu-mx1a-1u
S3:4: K_K; bwu-mx1a-1u
S3:5: K_X; bwu-mx1a-1u
S3:6: K_DEL; bwu-mx1a-1u
S3:7: K_INS; bwu-mx1a-1u
S3:8: K_B; bwu-mx1a-1u
S3:9: K_M; bwu-mx1a-1u
S3:10: K_W; bwu-mx1a-1u
S3:11: K_V; bwu-mx1a-1u
S3:12: K_Z; bwu-mx1a-1u
S3:13: K_RSHFT; bwu-mx1a-150u
S4:0: K_LCTRL; bwu-mx1a-125u
S4:1: K_LGUI; bwu-mx1a-125u
S4:2: K_LALT; bwu-mx1a-125u
S4:3: K_LFN; bwu-mx1a-125u
S4:5: K_BKSPC; bwu-mx1a-150u
S4:6: K_SPACE; bwu-mx1a-2u
S4:8: K_ENTER; bwu-mx1a-150u
S4:10: K_RFN; bwu-mx1a-125u
S4:11: K_RALT; bwu-mx1a-125u
S4:12: K_RGUI; bwu-mx1a-125u
S4:13: K_RCTRL; bwu-mx1a-125u
SW1: SW423CT-ND; bwu-SW423CT-ND
Y1: 16MHz; bwu-ABM8G-16.000MHZ-4Y-T3

Connections:
/AREF: C7.1, IC1.42 (AREF)
/C0: D0:0.2 (K), D1:0.2 (K), D2:0.2 (K), D3:0.2 (K), D4:0.2 (K), IC1.37 ((ADC6/TDO)PF6)
/C1: D0:1.2 (K), D1:1.2 (K), D2:1.2 (K), D3:1.2 (K), D4:1.2 (K), IC1.32 ((ICP3/CLK0/OC4A)PC7)
/C2: D0:2.2 (K), D1:2.2 (K), D2:2.2 (K), D3:2.2 (K), D4:2.2 (K), IC1.31 ((OC3A/~OC4A~)PC6)
/C3: D0:3.2 (K), D1:3.2 (K), D2:3.2 (K), D3:3.2 (K), D4:3.2 (K), IC1.30 ((PCINT6/OC1B/OC4B/ADC13)PB6)
/C4: D0:4.2 (K), D1:4.2 (K), D2:4.2 (K), D3:4.2 (K), IC1.29 ((PCINT5/OC1A/~OC4B~/ADC12)PB5)
/C5: D0:5.2 (K), D1:5.2 (K), D2:5.2 (K), D3:5.2 (K), D4:5.2 (K), IC1.28 ((PCINT4/ADC11)PB4)
/C6: D0:6.2 (K), D1:6.2 (K), D2:6.2 (K), D3:6.2 (K), D4:6.2 (K), IC1.27 ((T0/OC4D/ADC10)PD7)
/C7: D0:7.2 (K), D1:7.2 (K), D2:7.2 (K), D3:7.2 (K), IC1.25 ((ICP1/ADC8)PD4)
/C8: D0:8.2 (K), D1:8.2 (K), D2:8.2 (K), D3:8.2 (K), D4:8.2 (K), IC1.9 ((PCINT1/SCLK)PB1)
/C9: D0:9.2 (K), D1:9.2 (K), D2:9.2 (K), D3:9.2 (K), IC1.12 ((PCINT7/OC0A/OC1C/~RTS~)PB7)
/CA: D0:10.2 (K), D1:10.2 (K), D2:10.2 (K), D3:10.2 (K), D4:10.2 (K), IC1.18 ((OC0B/SCL/INT0)PD0)
/CA1: IC2.21, LED1.1, LED1.2, LED1.4, LED2.4, LED3.4, LED4.4, LED5.4, LED6.4, LED7.4
/CA2: IC2.22, LED1.3, LED1.5, LED2.1, LED2.5, LED3.5, LED4.5, LED5.5, LED6.5, LED7.5
/CA3: IC2.23, LED1.6, LED2.2, LED2.3, LED2.6, LED3.6, LED4.6, LED5.6, LED6.6, LED7.6
/CA4: IC2.24, LED3.1, LED3.2, LED3.3
/CA5: IC2.25, LED4.1, LED4.2, LED4.3
/CA6: IC2.26, LED5.1, LED5.2, LED5.3
/CA7: IC2.27, LED6.1, LED6.2, LED6.3
/CA8: IC2.28, LED7.1, LED7.2, LED7.3
/CA9: IC2.1
/CB: D0:11.2 (K), D1:11.2 (K), D2:11.2 (K), D3:11.2 (K), D4:11.2 (K), IC1.19 ((SDA/INT1)PD1)
/CC: D0:12.2 (K), D1:12.2 (K), D2:12.2 (K), D3:12.2 (K), D4:12.2 (K), IC1.20 ((RXD1/INT2)PD2)
/CD: D0:13.2 (K), D1:13.2 (K), D2:13.2 (K), D3:13.2 (K), D4:13.2 (K), IC1.21 ((TXD1/INT3)PD3)
/D+: IC1.4 (D+), R2.1
/D-: IC1.3 (D-), R1.1
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, CON1.5 (GND), CON1.6 (SHELL1), CON1.7 (SHELL2), IC1.5 (UGnd), IC1.15 (GND), IC1.23 (GND), IC1.35 (GND), IC1.43 (GND), IC2.5, IC2.18, R3.1, R7.1, R8.1, SW1.4, Y1.2, Y1.4
/INTB: IC1.40 ((ADC1)PF1), IC2.4, R6.1
/R0: IC1.8 ((SS/PCINT0)PB0), S0:0.1, S0:1.1, S0:2.1, S0:3.1, S0:4.1, S0:5.1, S0:6.1, S0:7.1, S0:8.1, S0:9.1, S0:10.1, S0:11.1, S0:12.1, S0:13.1
/R1: IC1.1 ((INT6/AIN0)PE6), S1:0.1, S1:1.1, S1:2.1, S1:3.1, S1:4.1, S1:5.1, S1:6.1, S1:7.1, S1:8.1, S1:9.1, S1:10.1, S1:11.1, S1:12.1, S1:13.1
/R2: IC1.36 ((ADC7/TDI)PF7), S2:0.1, S2:1.1, S2:2.1, S2:3.1, S2:4.1, S2:5.1, S2:6.1, S2:7.1, S2:8.1, S2:9.1, S2:10.1, S2:11.1, S2:12.1, S2:13.1
/R3: IC1.22 ((XCK1/~CTS~)PD5), S3:0.1, S3:1.1, S3:2.1, S3:3.1, S3:4.1, S3:5.1, S3:6.1, S3:7.1, S3:8.1, S3:9.1, S3:10.1, S3:11.1, S3:12.1, S3:13.1
/R4: IC1.26 ((T1/~OC4D~/ADC9)PD6), S4:0.1, S4:1.1, S4:2.1, S4:3.1, S4:5.1, S4:6.1, S4:8.1, S4:10.1, S4:11.1, S4:12.1, S4:13.1
/RESET: IC1.13 (~RESET~), SW1.2
/SCL: IC1.39 ((ADC4/TCK)PF4), IC2.20, R5.2
/SDA: IC1.38 ((ADC5/TMS)PF5), IC2.19, R4.1
/SDB: IC1.41 ((ADC0)PF0), IC2.3, R7.2
/UCAP: C8.1, IC1.6 (Ucap)
/USB_D+: CON1.3 (D+), R2.2
/USB_D-: CON1.2 (D-), R1.2
/VCC: C1.1, C2.1, C3.1, C6.1, CON1.1 (VBUS), IC1.2 (UVcc), IC1.7 (VBus), IC1.14 (VCC), IC1.24 (AVCC), IC1.34 (VCC), IC1.44 (AVCC), IC2.2, R4.2, R5.1, R6.2
/XTAL+: C4.1, IC1.16 (XTAL2), Y1.3
/XTAL-: C5.1, IC1.17 (XTAL1), Y1.1
unnamed: C9.2, IC2.17
unnamed: C10.1, IC2.16
unnamed: D0:0.1 (A), S0:0.2
unnamed: D0:1.1 (A), S0:1.2
unnamed: D0:2.1 (A), S0:2.2
unnamed: D0:3.1 (A), S0:3.2
unnamed: D0:4.1 (A), S0:4.2
unnamed: D0:5.1 (A), S0:5.2
unnamed: D0:6.1 (A), S0:6.2
unnamed: D0:7.1 (A), S0:7.2
unnamed: D0:8.1 (A), S0:8.2
unnamed: D0:9.1 (A), S0:9.2
unnamed: D0:10.1 (A), S0:10.2
unnamed: D0:11.1 (A), S0:11.2
unnamed: D0:12.1 (A), S0:12.2
unnamed: D0:13.1 (A), S0:13.2
unnamed: D1:0.1 (A), S1:0.2
unnamed: D1:1.1 (A), S1:1.2
unnamed: D1:2.1 (A), S1:2.2
unnamed: D1:3.1 (A), S1:3.2
unnamed: D1:4.1 (A), S1:4.2
unnamed: D1:5.1 (A), S1:5.2
unnamed: D1:6.1 (A), S1:6.2
unnamed: D1:7.1 (A), S1:7.2
unnamed: D1:8.1 (A), S1:8.2
unnamed: D1:9.1 (A), S1:9.2
unnamed: D1:10.1 (A), S1:10.2
unnamed: D1:11.1 (A), S1:11.2
unnamed: D1:12.1 (A), S1:12.2
unnamed: D1:13.1 (A), S1:13.2
unnamed: D2:0.1 (A), S2:0.2
unnamed: D2:1.1 (A), S2:1.2
unnamed: D2:2.1 (A), S2:2.2
unnamed: D2:3.1 (A), S2:3.2
unnamed: D2:4.1 (A), S2:4.2
unnamed: D2:5.1 (A), S2:5.2
unnamed: D2:6.1 (A), S2:6.2
unnamed: D2:7.1 (A), S2:7.2
unnamed: D2:8.1 (A), S2:8.2
unnamed: D2:9.1 (A), S2:9.2
unnamed: D2:10.1 (A), S2:10.2
unnamed: D2:11.1 (A), S2:11.2
unnamed: D2:12.1 (A), S2:12.2
unnamed: D2:13.1 (A), S2:13.2
unnamed: D3:0.1 (A), S3:0.2
unnamed: D3:1.1 (A), S3:1.2
unnamed: D3:2.1 (A), S3:2.2
unnamed: D3:3.1 (A), S3:3.2
unnamed: D3:4.1 (A), S3:4.2
unnamed: D3:5.1 (A), S3:5.2
unnamed: D3:6.1 (A), S3:6.2
unnamed: D3:7.1 (A), S3:7.2
unnamed: D3:8.1 (A), S3:8.2
unnamed: D3:9.1 (A), S3:9.2
unnamed: D3:10.1 (A), S3:10.2
unnamed: D3:11.1 (A), S3:11.2
unnamed: D3:12.1 (A), S3:12.2
unnamed: D3:13.1 (A), S3:13.2
unnamed: D4:0.1 (A), S4:0.2
unnamed: D4:1.1 (A), S4:1.2
unnamed: D4:2.1 (A), S4:2.2
unnamed: D4:3.1 (A), S4:3.2
unnamed: D4:5.1 (A), S4:5.2
unnamed: D4:6.1 (A), S4:6.2
unnamed: D4:8.1 (A), S4:8.2
unnamed: D4:10.1 (A), S4:10.2
unnamed: D4:11.1 (A), S4:11.2
unnamed: D4:12.1 (A), S4:12.2
unnamed: D4:13.1 (A), S4:13.2
unnamed: IC1.33 ((~HWB~)PE2), R3.2
unnamed: IC2.6, R8.2

Board: 2 copper layers, 285.8 x 97.2 mm, 164 parts (67 on the bottom side), 113 nets.

## Commit log

2015-08-02 usb footprint
2015-08-02 annotations in schematic
2015-08-02 gitignore update
2015-08-03 mx1a footprints
2015-08-06 added crystal module
2015-08-06 update gitignore
2015-08-06 update gitignore again
2015-08-06 ignore cache lib
2015-08-06 update gitignore, remove some stuff that shouldn't be here
2015-08-06 update usb footprint with keepout zone and part area
2015-08-06 update schematic and add pcb
2015-08-06 new reset switch schematic and footprint
2015-08-06 clean up inventor stuff
2015-08-06 ignore inventor stuff
2015-08-09 changing usb footprint slots to circles
2015-08-09 schematic cleanup
2015-08-17 revision submitted to dirtypcb
2015-08-30 small schematic changes
2015-08-30 firmware first commit note: doesn't work yet todo: cleanup
2015-08-31 firmware updates -- compiles now
2015-08-31 cleanup temp files
2015-09-30 updated schematic for full 60% keyboard TODO: matrix pin assignments are temp TODO: add NPNs for RGB LEDs TODO: may want to consider a second set of LED outputs for a second PWM phase?
2015-09-30 enlarging pads for smd crystal
2015-10-17 first routing pass finished
2015-10-26 fix pad assignment on 5060BRG4
2015-10-26 replacing mosfets with dedicated led driver chip
2015-10-26 adding ground fill to front side of pcb
2015-10-27 some routing cleanup
2015-11-08 hermes rev. 1
2015-12-09 Removing firmware.
2015-12-18 cleaning up unneeded files
2015-12-18 add case DWGs
2015-12-18 renaming files
2015-12-29 library cleanup
2015-12-29 re-add missing device schematic library
2015-12-29 add missing mx1a switch schematic
2015-12-29 library cleanup (SOD123)
2016-01-09 renaming folder
2016-01-09 reorganizing
2016-01-09 missed a file
2016-01-09 add more sizes of keycap footprints
2016-01-10 aphrodite first commit -- schematic and partial pcb routing done
2016-01-10 ignore autocad temp files
2016-01-11 first pass on aphrodite routing
2016-01-11 adding layout
2016-01-11 cleanup aphrodite layout
2016-02-06 aphrodite rev 1
2017-02-05 first pass at layout for gaia
2017-02-05 add insert key, move delete key
2017-02-07 added function keys changed angle between halves from 30 to 20 degrees moved a bunch of keys around, particularly around thumb area, to make overall footprint smaller
2017-02-12 gaia schematic; leds tbd; pin assignments subject to change
2017-02-13 add color(-coded) layout jsons
2017-08-28 gaia work -- need to rotate switches on pcb still
2018-02-09 fix schematic error
2018-02-15 routing
2018-04-18 new footprints because i'm a dummy who put all the keys on the wrong side of the board
    the correct way to fix this would be to just move the keys to the other side but i don't want to rewire everything
2018-04-18 lots of changes to pcb layout -- almost ready for rotation and final routing
2018-05-06 footprints for reverse mount smd leds
2018-05-25 fix layer of cutout
2018-05-25 checkpointing
2019-10-10 add readme
